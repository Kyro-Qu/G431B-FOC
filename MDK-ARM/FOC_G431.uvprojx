# Keil uVision project FOC_G431.uvprojx, settings and files
target FOC_G431 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,ARM_MATH_CM4
  c misc: --diag_suppress=1,111
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./Code/foc/App;./Code/foc/Core;./Code/foc/HAL;./Code/foc/Driver;./Code/foc/Driver/encoder;./Code/foc/Driver/current;./Code/foc/Driver/hall
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group FOC/Core
    ./Code/foc/Core/: foc_pid.c foc_svm.c foc_motor.c foc_observer.c foc_traj.c
  group FOC/App
    ./Code/foc/App/: foc_app.c foc_calib.c foc_cmd.c foc_telemetry.c foc_ident.c
  group FOC/Driver
    ./Code/foc/Driver/encoder/: abz_encoder.c
    ./Code/foc/Driver/current/: current_shunt.c
    ./Code/foc/Driver/hall/: hall_sensor.c
  group FOC/HAL
    ./Code/foc/HAL/: foc_board_g431.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.17.0
